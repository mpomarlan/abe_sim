Commit message: Fixes for cover/uncover.

File: src/abe_sim/3DObjects/MediumBowl/mediumbowlLid.urdf (robot description, URDF)
Before this commit: robot mediumbowlLid, 1 links, 0 joints
Links:
- link lid: geometry collision mesh filename=lidCollider.obj; visual mesh filename=mediumBowlLid.obj
